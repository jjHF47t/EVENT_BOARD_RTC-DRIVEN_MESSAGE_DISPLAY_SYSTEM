# Keil uVision project mini project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: rtc_test +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s lcd_defines.h lcd.h types.h lcd.c defines.h KPM.c KPM.h KPM_defines.h ADC_defines.h ADC.h ADC.c mini_project_main.c
